# Repository do-del/DK_Board

## KiCad design Hardware/ESP32_DK/ESP32_DK.kicad_pcb

Parts:
C1, C13, C14: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C16, C20: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5, C6, C8, C9, C15, C17, C19, C21: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C10, C12: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C18: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: 5819; D_SOD-323_HandSoldering
J1: Conn_01x02_Male; SH1.0_01x02P_WT
Q1, Q2: S8050; SOT-23
R1, R2, R4, R5, R6, R7, R16, R17: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 2.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 5K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R11, R12: 4.7K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 560K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SD1: TF-Card; TF_CARD
SW1, SW2: KEY; SW_3x4
U1: ESP32-WROOM-32U
U2: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U3: BMI270; Bosch_LGA-14_3x2.5mm_P0.5mm
U4: OLED_14P_091; 0.91_OLED_14P
U5: CH340K; ESSOP-10_P1.0_3.9
U6: SPX3819M5-L-3-3; SOT-23-5
USB1: Type_C_16PIN; TYPE-C-16PIN_SMD

Connections:
+3.3V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C20.1, D2.1 (K), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.2, R9.1, R11.1, R12.1, SD1.4 (VDD), U1.2 (VDD), U2.3 (VCC), U3.5 (VDDIO), U3.8 (VDD), U4.5 (VBAT), U4.8 (VDD), U6.5 (OUT)
+5V: C16.1, C17.1, C19.2, U5.7 (VCC), U6.1 (IN), U6.3 (EN), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/CAN_H: J1.2, R10.1, U2.7 (CANH)
/CAN_L: J1.1, R10.2, U2.6 (CANL)
/CAN_RX: U1.8 (IO32), U2.4 (R)
/CAN_TX: U1.9 (IO33), U2.1 (D)
/CLK: SD1.5 (CLK), U1.13 (IO14)
/CMD: R5.2, SD1.3 (CMD), U1.23 (IO15)
/CS: U1.29 (IO5), U3.12 (CSB)
/D+: U5.1 (UD+), USB1.A6 (DP1), USB1.B6 (DP2)
/D-: U5.2 (UD-), USB1.A7 (DN1), USB1.B7 (DN2)
/DATA0: R2.2, SD1.7 (DAT0), U1.24 (IO2)
/DATA1: R1.2, SD1.8 (DAT1), U1.26 (IO4)
/DATA2: R7.2, SD1.1 (DAT2), U1.14 (IO12)
/DATA3: R6.2, SD1.2 (DAT3/CD), U1.16 (IO13)
/DTR: Q2.3 (C), R16.1, U5.4 (DTR#)
/ESP_EN: C1.1, Q1.3 (C), R4.2, SW1.2 (B), U1.3 (EN)
/ESP_RX: U1.34 (RXD0/IO3), U5.8 (TXD)
/ESP_TX: U1.35 (TXD0/IO1), U5.9 (RXD)
/GYRO_INT: U1.28 (IO17), U3.4 (INT1)
/IO0: Q2.2 (E), R8.1, SW2.1 (A), U1.25 (IO0)
/IO16: D1.1 (K), U1.27 (IO16)
/IO18: U1.30 (IO18), U3.13 (SCK)
/IO19: U1.31 (IO19), U3.1 (SDO)
/IO21: R12.2, U1.33 (IO21), U4.11 (SDA)
/IO22: R11.2, U1.36 (IO22), U4.10 (SCL)
/IO23: U1.37 (IO23), U3.14 (SDX)
/IO34: U1.6 (IO34)
/IO35: U1.7 (IO35)
/IO36: U1.4 (SENSOR_VP)
/IO39: U1.5 (SENSOR_VN)
/RTS: Q1.2 (E), R17.1, U5.6 (RTS#)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.2, R13.1, R14.2, R15.2, SD1.6 (VSS), SD1.10 (SHIELD), SW1.1 (A), SW2.2 (B), U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (GND), U3.6 (GNDIO), U3.7 (GND), U4.7 (VSS), U5.3 (GND), U5.11 (EP), U6.2 (GND), USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: D1.2 (A), R3.2
unnamed: C10.1, D2.2 (A), R9.2, U4.9 (~RES)
unnamed: Q1.1 (B), R16.2
unnamed: Q2.1 (B), R17.2
unnamed: C14.1, U4.4 (C1N)
unnamed: C14.2, U4.3 (C1P)
unnamed: C13.1, U4.2 (C2N)
unnamed: C13.2, U4.1 (C2P)
unnamed: C11.1, U4.13 (CVOMH)
unnamed: R13.2, U4.12 (IREF)
unnamed: C12.1, C15.1, U4.14 (VCC)
unnamed: C21.1, U5.10 (V3)
unnamed: C18.1, U6.4 (BP)
unnamed: R14.1, USB1.A5 (CC1)
unnamed: R15.1, USB1.B5 (CC2)

Notes on the sheet:
IMU
TF-CARD
Strapping:IO15上拉 IO12下拉 IO2下拉 IO5上拉 IO0上拉
ESP32
CAN
PROG

Board: 2 copper layers, 39.9 x 53.7 mm, 52 parts (0 on the bottom side), 44 nets.

## KiCad design Hardware/STM32H7_DK/STM32H7_DK.kicad_pcb

Parts:
C1, C3, C7, C8, C9, C10, C13, C14, C17, C19, C20, C25, C26, C28, C29, C30, C33, C34, C36, C37, C39: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5, C6, C11, C12, C35, C41: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C16: 100pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C27: 20pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C21, C22: 12pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C32, C40: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C38: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: BAT54C; SOT-23
D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: OV2640; OV2640_FPC0.5MM_24P_REVERSE
J2, J3: Conn_02x20_Counter_Clockwise; PinSocket_2x20_P2.54mm_Vertical
J4: Conn_01x02_Male; SH1.0_01x02P_WT
L1, L2, L3, L4, L5: 500Ω@100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1: S8550; SOT-23
R1, R2, R3, R11, R12, R14, R16, R17, R18, R19, R23: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5: 5.1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R24: 4.7K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21, R22: 2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SD1: TF-Card; TF_CARD
SW1, SW2, SW3, SW4: KEY; SW_3x4
TFT1: 0.96IPS_8PFPC0.5MM; TE_0-1734839-8_1x08-1MP_P0.5mm_Horizontal
U1: XC6206P282MR; SOT-23
U2: XC6206P132MR; SOT-23
U3: BMI270; Bosch_LGA-14_3x2.5mm_P0.5mm
U4: STM32H7B0VBT6; LQFP-100_14x14mm_P0.5mm
U5: SN65HVD232; SOIC-8_3.9x4.9mm_P1.27mm
U6: SPX3819M5-L-3-3; SOT-23-5
U7: W25QXX_FLASH; SOIC-8_3.9x4.9mm_P1.27mm
USB1: Type_C_16PIN; TYPE-C-16PIN_SMD
X1: 24M有源晶振2520; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
Y1: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32768; Crystal_SMD_MicroCrystal_CM9V-T1A-2Pin_1.6x1.0mm_HandSolder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

Connections:
+2V8: C11.1, C13.1, J1.4 (AVDD), U1.2 (VO)
+3.3V: C1.1, C3.1, C17.1, C19.1, C20.1, C26.1, C30.1, C34.1, C36.1, C39.1, C41.1, D1.1, J3.3, J3.4, L1.1, L2.1, L3.1, L4.1, L5.1, Q1.2 (E), R1.1, R2.1, R3.2, R6.2, R7.2, R12.1, R14.1, R16.1, R17.1, R18.1, R19.1, R21.1, R22.1, R23.1, R24.1, SD1.4 (VDD), SW2.2 (B), TFT1.7 (VDD), U3.5 (VDDIO), U3.8 (VDD), U4.11 (VDD), U4.27 (VDD), U4.50 (VDD), U4.75 (VDD), U4.100 (VDD), U5.3 (VCC), U6.5 (OUT), U7.8 (VCC)
+5V: C35.1, C37.1, J2.3, J2.4, U6.1 (IN), U6.3 (EN), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
/1V3: C12.1, C14.1, J1.10 (DVDD), U2.2 (VO)
/BOOT0: R11.2, SW2.1 (A), U4.94 (BOOT0)
/CAN_H: J4.2, R13.1, U5.7 (CANH)
/CAN_L: J4.1, R13.2, U5.6 (CANL)
/CAN_RX: U4.51 (PB12), U5.4 (R)
/CAN_TX: U4.52 (PB13), U5.1 (D)
/DCMI_D0: J1.19 (Y2), U4.63 (PC6)
/DCMI_D1: J1.21 (Y3), U4.64 (PC7)
/DCMI_D2: J1.22 (Y4), U4.97 (PE0)
/DCMI_D3: J1.20 (Y5), U4.98 (PE1)
/DCMI_D4: J1.18 (Y6), U4.3 (PE4)
/DCMI_D5: J1.16 (Y7), U4.84 (PD3)
/DCMI_D6: J1.14 (Y8), U4.4 (PE5)
/DCMI_D7: J1.12 (Y9), U4.5 (PE6)
/DCMI_HS: J1.9 (HSYNC), U4.28 (PA4)
/DCMI_PCLK: J1.17 (PCLK), U4.30 (PA6)
/DCMI_VS: J1.7 (VSYNC), U4.93 (PB7)
/GYRO_CS: U3.12 (CSB), U4.88 (PD7)
/GYRO_INT: U3.4 (INT1), U4.87 (PD6)
/GYRO_MISO: U3.1 (SDO), U4.90 (PB4)
/GYRO_MOSI: U3.14 (SDX), U4.91 (PB5)
/GYRO_SCK: U3.13 (SCK), U4.89 (PB3)
/KEY_A: SW3.1 (A)
/KEY_B: SW4.1 (A)
/OSC32_IN: C21.2, U4.8 (PC14/OSC32_IN), Y2.2
/OSC32_OUT: C22.2, U4.9 (PC15/OSC32_OUT), Y2.1
/OSC_IN: C18.2, U4.12 (PH0/OSC_IN), Y1.1
/OSC_OUT: C27.1, U4.13 (PH1/OSC_OUT), Y1.3
/OV_RESET: C2.1, J1.6 (RESET), R2.2
/PA0: U4.22 (PA0)
/PA1: U4.23 (PA1)
/PA2: U4.24 (PA2)
/PA3: U4.25 (PA3)
/PA5: U4.29 (PA5)
/PA7: U4.31 (PA7)
/PA8: U4.67 (PA8)
/PA9: U4.68 (PA9)
/PA10: U4.69 (PA10)
/PA11: U4.70 (PA11), USB1.A7 (DN1), USB1.B7 (DN2)
/PA12: U4.71 (PA12), USB1.A6 (DP1), USB1.B6 (DP2)
/PA15: U4.77 (PA15)
/PB0: U4.34 (PB0)
/PB1: U4.35 (PB1)
/PB2: U4.36 (PB2), U7.6 (CLK)
/PB6: U4.92 (PB6), U7.1 (~CS)
/PB8: R8.2, U4.95 (PB8)
/PB9: R9.2, U4.96 (PB9)
/PB10: U4.46 (PB10)
/PB11: U4.47 (PB11)
/PB14: J3.10, U4.53 (PB14)
/PB15: J3.7, U4.54 (PB15)
/PC0: U4.15 (PC0)
/PC1: U4.16 (PC1)
/PC2: U4.17 (PC2)
/PC3: U4.18 (PC3)
/PC4: U4.32 (PC4)
/PC5: U4.33 (PC5)
/PC8: R16.2, SD1.7 (DAT0), U4.65 (PC8)
/PC9: R14.2, SD1.8 (DAT1), U4.66 (PC9)
/PC10: R19.2, SD1.1 (DAT2), U4.78 (PC10)
/PC11: R18.2, SD1.2 (DAT3/CD), U4.79 (PC11)
/PC12: SD1.5 (CLK), U4.80 (PC12)
/PC13: D2.1 (K), U4.7 (PC13)
/PD0: U4.81 (PD0)
/PD1: U4.82 (PD1)
/PD2: R17.2, SD1.3 (CMD), U4.83 (PD2)
/PD4: U4.85 (PD4)
/PD5: U4.86 (PD5)
/PD8: J3.8, U4.55 (PD8)
/PD9: J3.5, U4.56 (PD9)
/PD10: J3.6, U4.57 (PD10)
/PD11: U4.58 (PD11), U7.5 (DI)
/PD12: U4.59 (PD12), U7.2 (DO)
/PD13: U4.60 (PD13), U7.7 (~HOLD)
/PD14: J1.8 (PWDN), R3.1, U4.61 (PD14)
/PD15: R20.1, U4.62 (PD15)
/PE2: U4.1 (PE2), U7.3 (~WP)
/PE3: U4.2 (PE3)
/PE7: U4.37 (PE7)
/PE8: U4.38 (PE8)
/PE9: U4.39 (PE9)
/PE10: U4.40 (PE10)
/PE11: TFT1.8 (CS), U4.41 (PE11)
/PE12: TFT1.6 (SCL), U4.42 (PE12)
/PE13: U4.43 (PE13)
/PE14: TFT1.5 (SDA), U4.44 (PE14)
/PE15: TFT1.4 (RS), U4.45 (PE15)
/RST: C33.1, R12.2, SW1.2 (B), U4.14 (NRST)
/SWCLK: U4.76 (PA14/SWCLK)
/SWDIO: U4.72 (PA13/SWDIO)
/VBAT: C25.1, D1.3, U4.6 (VBAT)
/VBAT_EXT: D1.2
/VDDA: C28.1, L5.2, R10.1, U4.21 (VDDA)
/VREF: C29.1, R10.2, U4.20 (VREF+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.2, C20.2, C21.1, C22.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, D3.1 (K), J1.1 (NC), J1.2 (AGND), J1.15 (DGND), J1.23 (Y1), J1.24 (Y0), J2.1, J2.2, J3.1, J3.2, R4.2, R5.2, R11.1, SD1.6 (VSS), SD1.10 (SHIELD), SW1.1 (A), SW3.2 (B), SW4.2 (B), TFT1.2 (GND), TFT1.MP, U1.1 (GND), U2.1 (GND), U3.6 (GNDIO), U3.7 (GND), U4.10 (VSS), U4.19 (VSSA), U4.26 (VSS), U4.49 (VSS), U4.74 (VSS), U4.99 (VSS), U5.2 (GND), U6.2 (GND), U7.4 (GND), USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND), X1.2 (GND), Y1.2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
unnamed: C31.1, U4.48 (VCAP)
unnamed: C32.1, U4.73 (VCAP)
unnamed: D2.2 (A), R21.2
unnamed: D3.2 (A), R22.2
unnamed: C6.1, C10.1, J1.11 (DOVDD), L3.2
unnamed: C15.1, J1.5 (SCL), R6.1, R8.1
unnamed: C16.1, J1.3 (SDA), R7.1, R9.1
unnamed: J1.13 (XVCLK), X1.3 (OUT)
unnamed: Q1.1 (B), R20.2, R23.2
unnamed: Q1.3 (C), R25.1
unnamed: R25.2, TFT1.1 (LEDA)
unnamed: C38.1, R24.2, TFT1.3 (RESET)
unnamed: C4.1, C8.1, L1.2, U1.3 (VI)
unnamed: C5.1, C9.1, L2.2, U2.3 (VI)
unnamed: C40.1, U6.4 (BP)
unnamed: R4.1, USB1.A5 (CC1)
unnamed: R5.1, USB1.B5 (CC2)
unnamed: R1.2, X1.1 (Tri-State)
unnamed: C7.2, L4.2, X1.4 (VDD)

Notes on the sheet:
QSPI FLASH
采用W25Q64，8MB
使用QSPI四线模式驱动
摄像头DCMI接口
模拟电源
IMU
滤波电容
VBAT电源
0.96`IPS屏幕
自定义LED
CAN
KEY
USB-DFU下载模式
电源指示LED
副晶振
TF-CARD
LED
主晶振

Board: 4 copper layers, 63.5 x 40.6 mm, 93 parts (1 on the bottom side), 82 nets.

## Code that names these connections

File Firmware/H7_TEST/H7_TEST.ioc (part):

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Mcu.Name=STM32H7B0VBTx
Mcu.Package=LQFP100
Mcu.UserName=STM32H7B0VBTx
PA11.Signal=USB_OTG_HS_DM
PA12.Signal=USB_OTG_HS_DP
PA13.Mode=Serial_Wire
PA13.Signal=DEBUG_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=DEBUG_JTCK-SWCLK
PA4.Signal=DCMI_HSYNC
PA6.Signal=DCMI_PIXCLK
PB12.Mode=FDCAN_Activate
PB12.Signal=FDCAN2_RX
PB13.Mode=FDCAN_Activate
PB13.Signal=FDCAN2_TX
PB2.Signal=OCTOSPIM_P1_CLK
PB3.Signal=SPI1_SCK
PB4.Signal=SPI1_MISO
PB5.Signal=SPI1_MOSI
PB6.Signal=OCTOSPIM_P1_NCS
PB7.Signal=DCMI_VSYNC
PB8.Signal=I2C1_SCL
PB9.Signal=I2C1_SDA
PC10.Signal=SDMMC1_D2
PC11.Signal=SDMMC1_D3
PC12.Signal=SDMMC1_CK
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC6.Signal=DCMI_D0
PC7.Signal=DCMI_D1
PC8.Signal=SDMMC1_D0
PC9.Signal=SDMMC1_D1
PD11.Signal=OCTOSPIM_P1_IO0
PD12.Signal=OCTOSPIM_P1_IO1
PD13.Signal=OCTOSPIM_P1_IO3
PD14.Signal=GPIO_Output
PD15.Signal=GPIO_Output
PD2.Signal=SDMMC1_CMD
PD3.Signal=DCMI_D5
PE0.Signal=DCMI_D2
PE1.Signal=DCMI_D3
PE11.Mode=NSS_Signal_Hard_Input
PE11.Signal=SPI4_NSS
PE12.Mode=TX_Only_Simplex_Unidirect_Master
PE12.Signal=SPI4_SCK
PE14.Mode=TX_Only_Simplex_Unidirect_Master
PE14.Signal=SPI4_MOSI
PE15.Signal=GPIO_Output
PE2.Signal=OCTOSPIM_P1_IO2
PE4.Signal=DCMI_D4
PE5.Signal=DCMI_D6
PE6.Signal=DCMI_D7
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=100000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2023-01-04 添加STM32H7B0最小系统原理图
2023-01-05 STM32H7-DK开发板原理图添加TF卡座、IPS屏幕、FLASH部分
2023-01-09 添加原理图所有功能模块，但尚未连接节点
2023-01-10 添加H7的Cube MX测试文件
2023-02-20 尝试H7PCB布局，大量未连接端
2023-02-21 H7开始布线
2023-02-27 继续走线
2023-02-28 添加基于ESP32的SD卡以及BMI270测试PCB
2023-03-03 成功验证ESPSD卡功能
